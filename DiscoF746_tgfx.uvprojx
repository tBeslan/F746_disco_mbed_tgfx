# Keil uVision project DiscoF746_tgfx.uvprojx, settings and files
target Template ()
  pack: ..
  cpu: CPUTYPE("")
  c include: /home/beslan/MbedPrograms/DiscoF746_tgfx;/home/beslan/MbedPrograms/DiscoF746_tgfx/lib;/home/beslan/MbedPrograms/DiscoF746_tgfx/lib/Components;/home/beslan/MbedPrograms/DiscoF746_tgfx/lib/Components/Common;/home/beslan/MbedPrograms/DiscoF746_tgfx/lib/Components/ft5336;/home/beslan/MbedPrograms/DiscoF746_tgfx/lib/Components/n25q128a;/home/beslan/MbedPrograms/DiscoF746_tgfx/lib/Components/ov9655;/home/beslan/MbedPrograms/DiscoF746_tgfx/lib/Components/rk043fn48h;/home/beslan/MbedPrograms/DiscoF746_tgfx/lib/Components/wm8994;/home/beslan/MbedPrograms/DiscoF746_tgfx/lib/STM32746G-Discovery;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/cmsis;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/cmsis/CMSIS_5;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/cmsis/CMSIS_5/CMSIS;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/cmsis/CMSIS_5/CMSIS/RTOS2;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/cmsis/CMSIS_5/CMSIS/RTOS2/Include;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/cmsis/CMSIS_5/CMSIS/RTOS2/RTX;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/cmsis/CMSIS_5/CMSIS/RTOS2/RTX/Config;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/cmsis/CMSIS_5/CMSIS/RTOS2/RTX/Include;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/cmsis/CMSIS_5/CMSIS/RTOS2/RTX/Include1;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/cmsis/CMSIS_5/CMSIS/RTOS2/RTX/Source;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/cmsis/CMSIS_5/CMSIS/TARGET_CORTEX_M;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/cmsis/CMSIS_5/CMSIS/TARGET_CORTEX_M/Include;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/cmsis/device;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/cmsis/device/RTE;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/cmsis/device/RTE/include;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/cmsis/device/rtos;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/cmsis/device/rtos/include;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/connectivity;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/connectivity/libraries;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/connectivity/libraries/nanostack-libservice;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/connectivity/libraries/nanostack-libservice/mbed-client-libservice;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/connectivity/libraries/nanostack-libservice/mbed-client-libservice/platform;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/drivers;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/drivers/include;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/drivers/include/drivers;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/drivers/include/drivers/internal;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/events;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/events/include;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/events/include/events;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/events/include/events/internal;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/features;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/features/frameworks;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/features/frameworks/mbed-trace;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/features/frameworks/mbed-trace/mbed-trace;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/hal;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/hal/include;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/hal/include/hal;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/hal/usb;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/hal/usb/include;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/hal/usb/include/usb;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/platform;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/platform/cxxsupport;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/platform/include;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/platform/include/platform;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/platform/include/platform/internal;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/platform/source;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/platform/source/minimal-printf;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/rtos;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/rtos/include;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/rtos/include/rtos;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/rtos/include/rtos/internal;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/rtos/source;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/storage;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/storage/blockdevice;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/storage/blockdevice/COMPONENT_FLASHIAP;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/storage/blockdevice/COMPONENT_FLASHIAP/include;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/storage/blockdevice/COMPONENT_FLASHIAP/include/FlashIAP;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/storage/blockdevice/COMPONENT_QSPIF;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/storage/blockdevice/COMPONENT_QSPIF/include;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/storage/blockdevice/COMPONENT_QSPIF/include/QSPIF;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/storage/blockdevice/include;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/storage/blockdevice/include/blockdevice;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/storage/filesystem;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/storage/filesystem/fat;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/storage/filesystem/fat/ChaN;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/storage/filesystem/fat/include;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/storage/filesystem/fat/include/fat;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/storage/filesystem/include;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/storage/filesystem/include/filesystem;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/storage/filesystem/littlefs;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/storage/filesystem/littlefs/include;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/storage/filesystem/littlefs/include/littlefs;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/storage/filesystem/littlefs/littlefs;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/storage/filesystem/littlefsv2;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/storage/filesystem/littlefsv2/include;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/storage/filesystem/littlefsv2/include/littlefsv2;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/storage/filesystem/littlefsv2/littlefs;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/targets/TARGET_STM;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/targets/TARGET_STM/TARGET_STM32F7;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/targets/TARGET_STM/TARGET_STM32F7/STM32Cube_FW;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/targets/TARGET_STM/TARGET_STM32F7/STM32Cube_FW/CMSIS;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/targets/TARGET_STM/TARGET_STM32F7/STM32Cube_FW/STM32F7xx_HAL_Driver;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/targets/TARGET_STM/TARGET_STM32F7/STM32Cube_FW/STM32F7xx_HAL_Driver/Legacy;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/targets/TARGET_STM/TARGET_STM32F7/TARGET_STM32F746xG;/home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/targets/TARGET_STM/TARGET_STM32F7/TARGET_STM32F746xG/TARGET_DISCO_F746NG;/usr/arm-none-eabi/include/c++/10.2.0;/usr/arm-none-eabi/include/c++/10.2.0/arm-none-eabi;/usr/arm-none-eabi/include/c++/10.2.0/backward;/usr/lib/gcc/arm-none-eabi/10.2.0/include;/usr/lib/gcc/arm-none-eabi/10.2.0/include-fixed;/usr/arm-none-eabi/include
  group All Files
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/platform/cxxsupport/: mstd_algorithm mstd_atomic mstd_cstddef mstd_functional mstd_iterator mstd_memory mstd_mutex mstd_new mstd_tuple mstd_type_traits mstd_utility mstd_mutex.cpp
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/platform/source/TARGET_CORTEX_M/TOOLCHAIN_GCC/: except.S
    /home/beslan/MbedPrograms/DiscoF746_tgfx/lib/Components/Common/: audio.h camera.h lcd.h ts.h
    /home/beslan/MbedPrograms/DiscoF746_tgfx/lib/Components/ft5336/: ft5336.h ft5336.c
    /home/beslan/MbedPrograms/DiscoF746_tgfx/lib/Components/n25q128a/: n25q128a.h
    /home/beslan/MbedPrograms/DiscoF746_tgfx/lib/Components/ov9655/: ov9655.h ov9655.c
    /home/beslan/MbedPrograms/DiscoF746_tgfx/lib/Components/rk043fn48h/: rk043fn48h.h
    /home/beslan/MbedPrograms/DiscoF746_tgfx/lib/Components/wm8994/: wm8994.h wm8994.c
    /home/beslan/MbedPrograms/DiscoF746_tgfx/lib/STM32746G-Discovery/: stm32746g_discovery.h stm32746g_discovery_audio.h stm32746g_discovery_camera.h stm32746g_discovery_eeprom.h stm32746g_discovery_lcd.h stm32746g_discovery_qspi.h stm32746g_discovery_sd.h stm32746g_discovery_sdram.h stm32746g_discovery_ts.h stm32746g_discovery.c stm32746g_discovery_audio.c stm32746g_discovery_camera.c stm32746g_discovery_eeprom.c stm32746g_discovery_lcd.c stm32746g_discovery_qspi.c stm32746g_discovery_sd.c stm32746g_discovery_sdram.c stm32746g_discovery_ts.c
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/cmsis/CMSIS_5/CMSIS/RTOS2/Include/: cmsis_os2.h os_tick.h
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/cmsis/CMSIS_5/CMSIS/RTOS2/RTX/Config/: RTX_Config.h RTX_Config.c
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/cmsis/CMSIS_5/CMSIS/RTOS2/RTX/Include/: rtx_evr.h rtx_os.h
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/cmsis/CMSIS_5/CMSIS/RTOS2/RTX/Include1/: cmsis_os.h
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/cmsis/CMSIS_5/CMSIS/RTOS2/RTX/Source/: rtx_core_c.h rtx_core_ca.h rtx_core_cm.h rtx_lib.h rtx_delay.c rtx_evflags.c rtx_evr.c rtx_kernel.c rtx_lib.c rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_mutex.c rtx_semaphore.c rtx_system.c rtx_thread.c rtx_timer.c
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/cmsis/CMSIS_5/CMSIS/TARGET_CORTEX_M/Include/: arm_math.h cachel1_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm55.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h pmu_armv8.h tz_context.h
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/cmsis/device/RTE/include/: RTE_Components.h
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/cmsis/device/: mbed_cmsis_conf.h
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/cmsis/device/rtos/include/: mbed_boot.h mbed_rtx_conf.h mbed_rtx_storage.h
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/connectivity/libraries/nanostack-libservice/mbed-client-libservice/: common_functions.h ip4string.h ip6string.h ip_fsc.h ns_list.h ns_nvm_helper.h ns_trace.h ns_types.h nsdynmemLIB.h
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/connectivity/libraries/nanostack-libservice/mbed-client-libservice/platform/: arm_hal_interrupt.h arm_hal_nvm.h
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/drivers/include/drivers/: AnalogIn.h AnalogOut.h BufferedSerial.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h FlashIAP.h HighResClock.h I2C.h I2CSlave.h InterruptIn.h LowPowerClock.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h MbedCRC.h PortIn.h PortInOut.h PortOut.h PwmOut.h QSPI.h RealTimeClock.h ResetReason.h SPI.h SPISlave.h SerialBase.h SerialWireOutput.h Ticker.h TickerDataClock.h Timeout.h Timer.h TimerEvent.h USBAudio.h USBCDC.h USBCDC_ECM.h USBHID.h USBKeyboard.h USBMIDI.h USBMSD.h USBMouse.h USBMouseKeyboard.h USBSerial.h UnbufferedSerial.h Watchdog.h
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/drivers/include/drivers/internal/: AsyncOp.h ByteBuffer.h EndpointResolver.h LinkEntry.h LinkedList.h LinkedListBase.h MIDIMessage.h OperationList.h OperationListBase.h PolledQueue.h SFDP.h Task.h TaskBase.h TaskQueue.h USBAudio_Types.h USBDescriptor.h USBDevice.h USBDevice_Types.h USBHID_Types.h
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/events/include/events/: Event.h EventQueue.h UserAllocatedEvent.h equeue.h mbed_events.h mbed_shared_queues.h
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/events/include/events/internal/: equeue_platform.h
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/features/frameworks/mbed-trace/mbed-trace/: mbed_trace.h
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/hal/include/hal/: LowPowerTickerWrapper.h analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h crc_api.h critical_section_api.h dma_api.h flash_api.h gpio_api.h gpio_irq_api.h i2c_api.h itm_api.h lp_ticker_api.h mbed_lp_ticker_wrapper.h mpu_api.h pinmap.h port_api.h pwmout_api.h qspi_api.h reset_reason_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h static_pinmap.h ticker_api.h trng_api.h us_ticker_api.h watchdog_api.h
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/hal/usb/include/usb/: USBPhy.h USBPhyEvents.h USBPhyTypes.h usb_phy_api.h
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/: mbed.h
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/platform/include/platform/: ATCmdParser.h CThunk.h Callback.h CircularBuffer.h CriticalSectionLock.h DeepSleepLock.h DirHandle.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemHandle.h FileSystemLike.h LocalFileSystem.h NonCopyable.h PlatformMutex.h ScopedLock.h ScopedRamExecutionLock.h ScopedRomWriteLock.h SharedPtr.h SingletonPtr.h Span.h Stream.h Transaction.h mbed_application.h mbed_assert.h mbed_atomic.h mbed_chrono.h mbed_critical.h mbed_debug.h mbed_enum_flags.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_mktime.h mbed_mpu_mgmt.h mbed_poll.h mbed_power_mgmt.h mbed_preprocessor.h mbed_retarget.h mbed_rtc_time.h mbed_semihost_api.h mbed_stats.h mbed_thread.h mbed_toolchain.h mbed_version.h mbed_wait_api.h platform.h
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/platform/include/platform/internal/: CThunkBase.h SysTimer.h mbed_atomic_impl.h mbed_error_hist.h mbed_fault_handler.h mbed_os_timer.h
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/platform/source/: mbed_crash_data_offsets.h ATCmdParser.cpp CThunkBase.cpp CriticalSectionLock.cpp DeepSleepLock.cpp FileBase.cpp FileHandle.cpp FilePath.cpp FileSystemHandle.cpp LocalFileSystem.cpp Stream.cpp SysTimer.cpp mbed_alloc_wrappers.cpp mbed_mem_trace.cpp mbed_os_timer.cpp mbed_poll.cpp mbed_retarget.cpp mbed_rtc_time.cpp mbed_thread.cpp mbed_application.c mbed_assert.c mbed_atomic_impl.c mbed_board.c mbed_critical.c mbed_error.c mbed_error_hist.c mbed_interface.c mbed_mktime.c mbed_mpu_mgmt.c mbed_power_mgmt.c mbed_sdk_boot.c mbed_semihost_api.c mbed_stats.c mbed_wait_api_no_rtos.c
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/platform/source/minimal-printf/: mbed_printf_implementation.h mbed_printf_armlink_overrides.c mbed_printf_implementation.c mbed_printf_wrapper.c
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/rtos/include/rtos/: ConditionVariable.h EventFlags.h Kernel.h Mail.h MemoryPool.h Mutex.h Queue.h Semaphore.h ThisThread.h Thread.h mbed_rtos_types.h rtos.h
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/rtos/include/rtos/internal/: mbed_rtos1_types.h mbed_rtos_storage.h
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/rtos/source/: rtos_handlers.h rtos_idle.h ConditionVariable.cpp EventFlags.cpp Kernel.cpp Mutex.cpp Semaphore.cpp ThisThread.cpp Thread.cpp
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/storage/blockdevice/COMPONENT_FLASHIAP/include/FlashIAP/: FlashIAPBlockDevice.h
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/storage/blockdevice/COMPONENT_QSPIF/include/QSPIF/: QSPIFBlockDevice.h
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/storage/blockdevice/include/blockdevice/: BlockDevice.h BufferedBlockDevice.h ChainingBlockDevice.h ExhaustibleBlockDevice.h FlashSimBlockDevice.h HeapBlockDevice.h MBRBlockDevice.h ObservingBlockDevice.h ProfilingBlockDevice.h ReadOnlyBlockDevice.h SlicingBlockDevice.h
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/storage/filesystem/fat/ChaN/: diskio.h ff.h ffconf.h integer.h ff.cpp ffunicode.cpp
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/storage/filesystem/fat/include/fat/: FATFileSystem.h
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/storage/filesystem/include/filesystem/: Dir.h File.h FileSystem.h mbed_filesystem.h
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/storage/filesystem/littlefs/include/littlefs/: LittleFileSystem.h
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/storage/filesystem/littlefs/littlefs/: lfs.h lfs_util.h lfs.c lfs_util.c
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/storage/filesystem/littlefsv2/include/littlefsv2/: LittleFileSystem2.h
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/storage/filesystem/littlefsv2/littlefs/: lfs2.h lfs2_util.h lfs2.c lfs2_util.c
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/targets/TARGET_STM/: PeripheralPins.h PinNamesTypes.h PortNames.h USBPhyHw.h device.h gpio_object.h mbed_rtx.h nvic_addr.h rtc_api_hal.h serial_api_hal.h stm32_assert.h us_ticker_defines.h USBPhy_STM32.cpp analogin_api.c analogout_api.c can_api.c gpio_api.c gpio_irq_api.c hal_tick_overrides.c i2c_api.c lp_ticker.c mbed_crc_api.c mbed_overrides.c pinmap.c port_api.c pwmout_api.c qspi_api.c reset_reason.c rtc_api.c serial_api.c sleep.c stm_spi_api.c trng_api.c us_ticker.c watchdog_api.c
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/targets/TARGET_STM/TARGET_STM32F7/STM32Cube_FW/CMSIS/: stm32f722xx.h stm32f723xx.h stm32f730xx.h stm32f732xx.h stm32f733xx.h stm32f745xx.h stm32f746xx.h stm32f750xx.h stm32f756xx.h stm32f765xx.h stm32f767xx.h stm32f769xx.h stm32f777xx.h stm32f779xx.h stm32f7xx.h system_stm32f7xx.h
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/targets/TARGET_STM/TARGET_STM32F7/STM32Cube_FW/STM32F7xx_HAL_Driver/Legacy/: stm32_hal_legacy.h stm32f7xx_hal_can_legacy.h stm32f7xx_hal_can_legacy.c
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/targets/TARGET_STM/TARGET_STM32F7/STM32Cube_FW/STM32F7xx_HAL_Driver/: stm32f7xx_hal.h stm32f7xx_hal_adc.h stm32f7xx_hal_adc_ex.h stm32f7xx_hal_can.h stm32f7xx_hal_cec.h stm32f7xx_hal_cortex.h stm32f7xx_hal_crc.h stm32f7xx_hal_crc_ex.h stm32f7xx_hal_cryp.h stm32f7xx_hal_cryp_ex.h stm32f7xx_hal_dac.h stm32f7xx_hal_dac_ex.h stm32f7xx_hal_dcmi.h stm32f7xx_hal_dcmi_ex.h stm32f7xx_hal_def.h stm32f7xx_hal_dfsdm.h stm32f7xx_hal_dma.h stm32f7xx_hal_dma2d.h stm32f7xx_hal_dma_ex.h stm32f7xx_hal_dsi.h stm32f7xx_hal_eth.h stm32f7xx_hal_exti.h stm32f7xx_hal_flash.h stm32f7xx_hal_flash_ex.h stm32f7xx_hal_gpio.h stm32f7xx_hal_gpio_ex.h stm32f7xx_hal_hash.h stm32f7xx_hal_hash_ex.h stm32f7xx_hal_hcd.h stm32f7xx_hal_i2c.h stm32f7xx_hal_i2c_ex.h stm32f7xx_hal_i2s.h stm32f7xx_hal_irda.h stm32f7xx_hal_irda_ex.h stm32f7xx_hal_iwdg.h stm32f7xx_hal_jpeg.h stm32f7xx_hal_lptim.h stm32f7xx_hal_ltdc.h stm32f7xx_hal_ltdc_ex.h stm32f7xx_hal_mdios.h stm32f7xx_hal_mmc.h stm32f7xx_hal_nand.h stm32f7xx_hal_nor.h stm32f7xx_hal_pcd.h stm32f7xx_hal_pcd_ex.h stm32f7xx_hal_pwr.h stm32f7xx_hal_pwr_ex.h stm32f7xx_hal_qspi.h stm32f7xx_hal_rcc.h stm32f7xx_hal_rcc_ex.h stm32f7xx_hal_rng.h stm32f7xx_hal_rtc.h stm32f7xx_hal_rtc_ex.h stm32f7xx_hal_sai.h stm32f7xx_hal_sai_ex.h stm32f7xx_hal_sd.h stm32f7xx_hal_sdram.h stm32f7xx_hal_smartcard.h stm32f7xx_hal_smartcard_ex.h stm32f7xx_hal_smbus.h stm32f7xx_hal_spdifrx.h stm32f7xx_hal_spi.h stm32f7xx_hal_spi_ex.h stm32f7xx_hal_sram.h stm32f7xx_hal_tim.h stm32f7xx_hal_tim_ex.h stm32f7xx_hal_uart.h stm32f7xx_hal_uart_ex.h stm32f7xx_hal_usart.h stm32f7xx_hal_usart_ex.h stm32f7xx_hal_wwdg.h stm32f7xx_ll_adc.h stm32f7xx_ll_bus.h stm32f7xx_ll_cortex.h stm32f7xx_ll_crc.h stm32f7xx_ll_dac.h stm32f7xx_ll_dma.h stm32f7xx_ll_dma2d.h stm32f7xx_ll_exti.h stm32f7xx_ll_fmc.h stm32f7xx_ll_gpio.h stm32f7xx_ll_i2c.h stm32f7xx_ll_iwdg.h stm32f7xx_ll_lptim.h stm32f7xx_ll_pwr.h stm32f7xx_ll_rcc.h stm32f7xx_ll_rng.h stm32f7xx_ll_rtc.h stm32f7xx_ll_sdmmc.h stm32f7xx_ll_spi.h stm32f7xx_ll_system.h stm32f7xx_ll_tim.h stm32f7xx_ll_usart.h stm32f7xx_ll_usb.h stm32f7xx_ll_utils.h stm32f7xx_ll_wwdg.h stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dfsdm.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal_eth.c stm32f7xx_hal_exti.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_jpeg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_mdios.c stm32f7xx_hal_mmc.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_smbus.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_spi_ex.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_adc.c stm32f7xx_ll_crc.c stm32f7xx_ll_dac.c stm32f7xx_ll_dma.c stm32f7xx_ll_dma2d.c stm32f7xx_ll_exti.c stm32f7xx_ll_fmc.c stm32f7xx_ll_gpio.c stm32f7xx_ll_i2c.c stm32f7xx_ll_lptim.c stm32f7xx_ll_pwr.c stm32f7xx_ll_rcc.c stm32f7xx_ll_rng.c stm32f7xx_ll_rtc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_spi.c stm32f7xx_ll_tim.c stm32f7xx_ll_usart.c stm32f7xx_ll_usb.c stm32f7xx_ll_utils.c
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/targets/TARGET_STM/TARGET_STM32F7/STM32Cube_FW/: stm32f7xx_hal_conf.h system_stm32f7xx.c
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/targets/TARGET_STM/TARGET_STM32F7/TARGET_STM32F746xG/TARGET_DISCO_F746NG/: PeripheralNames.h PinNames.h PeripheralPins.c system_clock.c
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/targets/TARGET_STM/TARGET_STM32F7/TARGET_STM32F746xG/: cmsis_nvic.h flash_data.h objects.h
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/targets/TARGET_STM/TARGET_STM32F7/: can_device.h cmsis.h gpio_irq_device.h i2c_device.h objects.h pin_device.h pwmout_device.h spi_device.h us_ticker_data.h analogin_device.c analogout_device.c flash_api.c gpio_irq_device.c pwmout_device.c serial_device.c spi_api.c
    /home/beslan/MbedPrograms/DiscoF746_tgfx/: mbed_config.h
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/cmsis/device/rtos/source/: mbed_rtx_idle.cpp mbed_boot.c mbed_rtos_rtx.c mbed_rtx_handlers.c
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/drivers/source/: AnalogIn.cpp AnalogOut.cpp BufferedSerial.cpp BusIn.cpp BusInOut.cpp BusOut.cpp CAN.cpp DigitalIn.cpp DigitalInOut.cpp DigitalOut.cpp FlashIAP.cpp I2C.cpp I2CSlave.cpp InterruptIn.cpp MbedCRC.cpp PortIn.cpp PortInOut.cpp PortOut.cpp PwmOut.cpp QSPI.cpp ResetReason.cpp SFDP.cpp SPI.cpp SPISlave.cpp SerialBase.cpp SerialWireOutput.cpp Ticker.cpp Timeout.cpp Timer.cpp TimerEvent.cpp UnbufferedSerial.cpp Watchdog.cpp
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/drivers/source/usb/: AsyncOp.cpp ByteBuffer.cpp EndpointResolver.cpp LinkedListBase.cpp OperationListBase.cpp PolledQueue.cpp TaskBase.cpp USBAudio.cpp USBCDC.cpp USBCDC_ECM.cpp USBDevice.cpp USBHID.cpp USBKeyboard.cpp USBMIDI.cpp USBMSD.cpp USBMouse.cpp USBMouseKeyboard.cpp USBSerial.cpp
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/events/source/: EventQueue.cpp equeue_mbed.cpp mbed_shared_queues.cpp equeue.c equeue_posix.c
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/hal/source/: LowPowerTickerWrapper.cpp mbed_lp_ticker_wrapper.cpp mbed_pinmap_default.cpp static_pinmap.cpp mbed_compat.c mbed_critical_section_api.c mbed_flash_api.c mbed_gpio.c mbed_gpio_irq.c mbed_itm_api.c mbed_lp_ticker_api.c mbed_pinmap_common.c mbed_ticker_api.c mbed_us_ticker_api.c
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/hal/usb/source/: mbed_usb_phy.cpp
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/storage/blockdevice/COMPONENT_FLASHIAP/source/: FlashIAPBlockDevice.cpp
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/storage/blockdevice/COMPONENT_QSPIF/source/: QSPIFBlockDevice.cpp
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/storage/blockdevice/source/: BufferedBlockDevice.cpp ChainingBlockDevice.cpp ExhaustibleBlockDevice.cpp FlashSimBlockDevice.cpp HeapBlockDevice.cpp MBRBlockDevice.cpp ObservingBlockDevice.cpp ProfilingBlockDevice.cpp ReadOnlyBlockDevice.cpp SlicingBlockDevice.cpp
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/storage/filesystem/fat/source/: FATFileSystem.cpp
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/storage/filesystem/littlefs/source/: LittleFileSystem.cpp
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/storage/filesystem/littlefsv2/source/: LittleFileSystem2.cpp
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/storage/filesystem/source/: Dir.cpp File.cpp FileSystem.cpp
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/storage/platform/source/: PlatformStorage.cpp
    /home/beslan/MbedPrograms/DiscoF746_tgfx/src/: main.cpp
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/cmsis/CMSIS_5/CMSIS/RTOS2/RTX/Library/: cmsis_os1.c
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/cmsis/CMSIS_5/CMSIS/RTOS2/Source/: os_systick.c os_tick_ptim.c
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/cmsis/CMSIS_5/CMSIS/TARGET_CORTEX_M/Source/: mbed_tz_context.c
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/cmsis/device/rtos/TOOLCHAIN_GCC_ARM/: mbed_boot_gcc_arm.c
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/connectivity/libraries/nanostack-libservice/source/IPv6_fcf_lib/: ip_fsc.c
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/connectivity/libraries/nanostack-libservice/source/libBits/: common_functions.c
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/connectivity/libraries/nanostack-libservice/source/libList/: ns_list.c
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/connectivity/libraries/nanostack-libservice/source/libip4string/: ip4tos.c stoip4.c
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/connectivity/libraries/nanostack-libservice/source/libip6string/: ip6tos.c stoip6.c
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/connectivity/libraries/nanostack-libservice/source/nsdynmemLIB/: nsdynmemLIB.c
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/connectivity/libraries/nanostack-libservice/source/nvmHelper/: ns_nvm_helper.c
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/features/frameworks/mbed-trace/source/: mbed_trace.c
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/hal/source/mpu/: mbed_mpu_v7m.c mbed_mpu_v8m.c
    /home/beslan/MbedPrograms/DiscoF746_tgfx/mbed-os/platform/source/TARGET_CORTEX_M/: mbed_fault_handler.c
